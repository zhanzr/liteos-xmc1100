# Keil uVision project LiteOS.uvprojx, settings and files
target TinyOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: XMC1100-T038x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.7.1
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_1
  c include: ..\..\platform\xmc1100_bootkit;..\..\example\include;..\..\kernel\base\core;..\..\kernel\base\fs;..\..\kernel\base\include;..\..\kernel\base\ipc;..\..\kernel\base\mem;..\..\kernel\base\misc;..\..\kernel\cpu\arm\cortex-m0;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\include;..\..\kernel\link\keil;..\..\platform\xmc1100_bootkit;..\..\user
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm0
    ../../kernel/cpu/arm/cortex-m0/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_cortexm0.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/xmc1100
    ../../platform/xmc1100_bootkit/: XMC1000_tseRoutine.c los_bsp_led.c los_bsp_adapter.c lcd2004.c lcd_pwm_vo.c los_bsp_uart.c xmc1100_it.c rtc.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/xmc1100_bootkit/: note.txt
  group user
    ../../platform/xmc1100_bootkit/: main.c
  group doc
    ../../: README.md
software components: CMSIS:CORE 5.0.2, Device:RTE_Device 1.1.0, Device:Startup 2.0.0, Device:XMClib:CCU4 2.1.16, Device:XMClib:FLASH 2.1.16, Device:XMClib:GPIO 2.1.16, Device:XMClib:I2C 2.1.16, Device:XMClib:PRNG 2.1.16, Device:XMClib:RTC 2.1.16, Device:XMClib:SCU 2.1.16, Device:XMClib:UART 2.1.16, Device:XMClib:WDT 2.1.16, Compiler:I/O:STDOUT 1.2.1
