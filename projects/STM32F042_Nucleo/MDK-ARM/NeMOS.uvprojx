# Keil uVision project NeMOS.uvprojx, settings and files
target NeMOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NeMOS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6,RAM_SIZE_LEVEL_0
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\..\..\platform\STM32F042_Nucleo;..\..\..\example\include;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\config;..\..\..\kernel\cpu\arm\cortex-m0;C:\Keil_v5\ARM\CMSIS\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c adc.c usart.c gpio.c dma.c
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_flash.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_i2c.c
  group kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../kernel/base/misc/: los_misc.c
  group cpu/cm0
    ../../../kernel/cpu/arm/cortex-m0/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_cortexm0.s
  group platform/stm32f042
    ../../../platform/STM32F042_Nucleo/: retarget_io_drv.c
  group example
    ../../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group doc
    ../../../: README.md
  group cmsis_os_if
    ../../../kernel/cmsis/: cmsis_liteos.c
  group config
    ../../../kernel/config/: los_config.c
software components: CMSIS:CORE 5.1.1, Compiler:I/O:STDOUT 1.2.1
